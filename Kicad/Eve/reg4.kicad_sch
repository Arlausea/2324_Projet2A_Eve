File: Kicad/Eve/reg4.kicad_sch (KiCad schematic)
At the start: 11 parts

Commit message: update pcb
Parts:
- gave numbers to parts that had none: 9
